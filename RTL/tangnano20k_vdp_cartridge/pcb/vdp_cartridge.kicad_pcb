# Repository hra1129/TangCartMSX

File README.md:

MSX用に TangNano9K を搭載したカートリッジを作成し、
そこにいろいろ機能を詰め込んでいく試みの制作物を置く場所。

LICENSE に記載のとおり、無保証の試作物です。
自動車等の乗り物や、医療、軍事等、人命にかかわるようなものへ、
一部または全部を転用する行為は厳禁です。

## KiCad design RTL/tangnano20k_vdp_cartridge/pcb/vdp_cartridge.kicad_pcb

Parts:
C1: 100uF; CP_Radial_D5.0mm_P2.50mm
C2, C4, C5, C6, C7, C8, C9: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3: 15pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
Q1, Q2, Q3: NMOS; MOSFET(SMD)
R2, R4, R5: 10kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SlideSwitch
U1: CLOCK
U2: TangNano20K
U3: MSX Cartridge_2
U4, U5, U6: SSOP-24_5.3x8.2mm_P0.65mm

Connections:
3V3: C2.1, C4.1, C6.1, C8.1, R5.1, SW1.1, U1.4 (3V3), U2.19 (3V3), U4.1 (VCCA), U5.1 (VCCA), U6.1 (VCCA)
5V: C1.1, C5.1, C7.1, C9.1, U2.40 (5V), U3.45 (+5V), U3.47 (+5V), U4.23 (VCCB), U4.24 (VCCB), U5.23 (VCCB), U5.24 (VCCB), U6.23 (VCCB), U6.24 (VCCB)
A0: U3.28 (A0), U5.21 (B1)
A1: U3.27 (A1), U5.20 (B2)
A2: U3.30 (A2), U5.19 (B3)
A3: U3.29 (A3), U5.18 (B4)
A4: U3.32 (A4), U5.17 (B5)
A5: U3.31 (A5), U5.16 (B6)
A6: U3.22 (A6), U5.15 (B7)
A7: U3.21 (A7), U5.14 (B8)
BUSDIR: Q1.2 (G), R2.1, U2.24 (IOT40B(72))
CLOCK: C3.1, U1.3 (CLK), U2.37 (IOT27A(80):SDIO_D2)
D0: U3.34 (D0), U4.21 (B1)
D1: U3.33 (D1), U4.20 (B2)
D2: U3.36 (D2), U4.19 (B3)
D3: U3.35 (D3), U4.18 (B4)
D4: U3.38 (D4), U4.17 (B5)
D5: U3.37 (D5), U4.16 (B6)
D6: U3.40 (D6), U4.15 (B7)
D7: U3.39 (D7), U4.14 (B8)
DIPSW: SW1.2, U2.18 (IOL49B(18))
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, Q1.3 (S), Q2.3 (S), Q3.3 (S), R2.2, R4.2, SW1.3, U1.2 (GND), U2.20 (GND), U2.26 (GND), U2.39 (GND), U3.41 (GND), U3.43 (GND), U4.11 (GND), U4.12 (GND), U4.13 (GND), U5.2 (DIR), U5.11 (GND), U5.12 (GND), U5.13 (GND), U6.2 (DIR), U6.11 (GND), U6.12 (GND), U6.13 (GND), U6.14 (B8), U6.16 (B6), U6.18 (B4), U6.20 (B2)
INT: Q3.2 (G), R4.1, U2.21 (IOR39A(52))
SLOT_A0: U2.13 (IOB14B(30)), U5.3 (A1)
SLOT_A1: U2.14 (IOB29A(31)), U5.4 (A2)
SLOT_A2: U2.38 (IOT30B(76)), U5.5 (A3)
SLOT_A3: U2.36 (IOB42B(42)), U5.6 (A4)
SLOT_A4: U2.35 (IOB43A(41)), U5.7 (A5)
SLOT_A5: U2.31 (IOR49B(48)), U5.8 (A6)
SLOT_A6: U2.29 (IOR49A(49)), U5.9 (A7)
SLOT_A7: U2.15 (IOL49A(17)), U5.10 (A8)
SLOT_D0: U2.12 (IOB14A(29)), U4.3 (A1)
SLOT_D1: U2.9 (IOB8B(28)), U4.4 (A2)
SLOT_D2: U2.8 (IOB8A(27)), U4.5 (A3)
SLOT_D3: U2.5 (IOT30A(77)), U4.6 (A4)
SLOT_D4: U2.4 (IOT4B(85):SDIO_D1), U4.7 (A5)
SLOT_D5: U2.3 (IOT34A(75)), U4.8 (A6)
SLOT_D6: U2.2 (IOT34B(74)), U4.9 (A7)
SLOT_D7: U2.1 (IOT40A(73)), U4.10 (A8)
SLOT_DATA_DIR: U2.17 (IOL51A(19)), U4.2 (DIR)
SLOT_IORQ_N: U2.23 (IOT44A(71)), U6.3 (A1)
SLOT_OE_N: U2.16 (IOL51B(20)), U4.22 (OEn), U5.22 (OEn), U6.22 (OEn)
SLOT_RD_N: U2.6 (IOL47A(15)), U6.7 (A5)
SLOT_RESET_N: U2.28 (IOT4A(86)), U6.9 (A7)
SLOT_WR_N: U2.7 (IOT47B(16)), U6.5 (A3)
WAIT: Q2.2 (G), R5.2, U2.22 (IOR38B(53))
/BUSDIR: Q1.1 (D), U3.10 (/BUSDIR)
/INT: Q3.1 (D), U3.8 (/INT)
/IORQ: U3.11 (/IORQ), U6.21 (B1)
/RD: U3.14 (/RD), U6.17 (B5)
/RESET: U3.15 (/RESET), U6.15 (B7)
/WAIT: Q2.1 (D), U3.7 (/WAIT)
/WR: U3.13 (/WR), U6.19 (B3)

Notes on the sheet:
SLOT_INT : 1 → /INT=0 0 or HiZ → /INT=HiZ
TO236AB Vgs(th) = 1.25V
En は、OPEN か H で CLK を出力、L で CLK が HiZ になる。
TangNano20K
BUSDIR 0: CPU → Cartridge (WRITE) 1: CPU ← Cartridge (READ)
14.318180MHz
※正論理
SLOT_WAIT : 1 or HiZ → /WAIT=0 0 → /WAIT=HiZ
SN74LVC8T245DBR 24SSOP
/BUSDIR 1: CPU → Cartridge (WRITE) 0: CPU ← Cartridge (READ)

Board: 2 copper layers, 95.2 x 82.4 mm, 25 parts (1 on the bottom side), 53 nets.

Other parts of the board:
G1: LOGO; usa_10x7
G2: LOGO; msxdiy_logo
G3: LOGO; msx_logo_15x5p8

## Commit log (part)

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2025-03-03 DDR3 Initialize passed
2025-03-09 Add a byte write and read test for TangPrimer20K_step2
2025-04-12 BG が崩れるバグを修正
    VRAM へのアクセスタイミングを調整し、SCREEN2 における BG が崩れる問題を修正した。
2025-06-14 Added
2025-06-21 Updated
    SDRAM ACCESS TIMING
    SCREEN0:W40 = OK
    SCREEN0:W80 = NO CHECK
    SCREEN1 = OK
    SCREEN2 = OK
    SCREEN3 = NO CHECK
2025-06-27 Migrate th9918 VDP files to th9958 and update timing logic
    Renamed and moved th9918 VDP source, testbench, and documentation files to the th9958 directory. Updated vdp_timing_control_ssg.v and its testbench to widen screen_pos_x to 13 bits, adjust c_left_pos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
2025-06-28 Add testbench and improve vdp_cpu_interface logic
    Added a new testbench directory with simulation scripts, testbench (tb.sv), and waveform configuration for vdp_cpu_interface. Refactored vdp_cpu_interface.v: removed unused initial_busy input, improv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
2025-06-29 Add color palette modules for VDP
    Introduced vdp_color_palette.v and vdp_color_palette_ram.v to implement color palette functionality for the VDP. Updated vdp_timing_control_ssg.v to correct a typo in the module description. Updated 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
2025-06-29 Add sprite timing control and RAM modules
    Introduced vdp_timing_control_sprite, vdp_timing_control_sprite_info_ram, and vdp_timing_control_sprite_line_ram modules for sprite timing and data storage. Updated vdp_color_palette.v to support spr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
2025-06-30 Update vram_rdata width to 32 bits in sprite timing
    Changed the vram_rdata input port in vdp_timing_control_sprite.v from 8 bits to 32 bits to support wider data access. Updated documentation to reflect recent design progress.
2025-06-30 Add VDP top and timing control modules
    Introduces vdp.v as the VDP top entity and vdp_timing_control.v for timing management. Updates vdp_timing_control_ssg.v to add intr_line and intr_frame outputs for interrupt signaling. These changes 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
2025-07-01 Add testbench for vdp_timing_control_g4567
    Added a new testbench directory with simulation scripts, testbench SystemVerilog file, and waveform configuration for vdp_timing_control_g4567. Fixed parameter and register naming in vdp_timing_contr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
2025-07-03 Refactor and fix vdp_timing_control_t12 logic
    Updated vdp_timing_control_t12.v to correct VRAM data width, improve phase handling, and fix pattern/color register logic for T2 mode. Adjusted testbench tb.sv to match new data width and removed obs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
2025-07-05 Initial commit
    Add initial project files and setup.
2025-07-08 Update rules for GitHub Copilot assistant
    Refined and clarified the operational and behavioral rules for the GitHub Copilot assistant, including response guidelines, content restrictions, and user interaction protocols.
2025-07-10 Add upscan modules and update VDP logic
    Added new vdp_upscan and vdp_upscan_line_buffer modules to the project. Updated project files and synthesis logs to include these modules. Modified VDP and related logic, including msx_slot and ip_gp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
2025-07-11 Refactor VDP timing and LED logic, update synthesis
    Reworked logic in vdp_timing_control_ssg and related modules to improve signal naming, combinational logic, and output assignments. Updated HDMI and send_data logic, removed unused wires, and fixed p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
2025-07-12 Updated
    CPUによる VRAM Read において、表示用の VRAM Read を妨害してしまう問題を修正。
    これにより、表示が乱れなくなりました。
2025-07-12 Refactor VDP timing and address logic, update LUTs
    Reworked LUT instantiations and wiring in tangnano20k_vdp_cartridge.vg and vdp_timing_control modules to improve address and timing control logic. Updated signal names, module interfaces, and LUT par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
2025-07-13 Add sprite info collector and makeup pixel modules
    Introduces vdp_sprite_info_collect.v and vdp_sprite_makeup_pixel.v for sprite plane information collection and pixel pattern makeup. Updates vdp_sprite_select_visible_planes.v to support new outputs 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
2025-07-15 Refactor sprite info collection and testbench
    Updated vdp_sprite_info_collect to use an internal info RAM and refactored interface to coordinate with select_visible_planes and makeup_pixel modules. Modified the testbench to match new signal conn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
2025-07-19 Add selected_x_en signal for sprite pixel makeup
    Introduces the selected_x_en output in vdp_sprite_info_collect and wires it through vdp_timing_control_sprite to vdp_sprite_makeup_pixel. This enables more precise control of sprite pixel makeup base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
2025-07-20 Refactor VDP modules and update signal naming
    This commit refactors the VDP core modules, renaming internal signals (e.g., n815_* to n821_*, ff_vram_valid_12 to ff_vram_valid_11, etc.), and updates LUT logic to improve clarity and consistency. I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
2025-07-21 Refactor VDP timing and address logic
    Reworked VDP timing control and address generation modules, including changes to LUT input assignments, signal wiring, and logic for vertical/horizontal active signals. Updated enable conditions and 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
2025-07-21 Refactor VDP logic and update synthesis outputs
    Reworked several LUT and wire assignments in vdp_cpu_interface and vdp_timing_control_ssg modules for improved logic clarity and resource usage. Updated synthesis and implementation output files to r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
2025-07-22 Refactor VDP register logic and add color0 opaque control
    Reworks the VDP register write logic, including significant changes to the address decoding and register enable signals. Adds a new output and register for reg_color0_opaque. Updates related LUTs, DF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
2025-07-22 Refactor VDP cartridge bus and address logic
    Updated signal naming and bus/address decoding logic across msx_slot, ip_gpio, and vdp_cpu_interface modules. Replaced and reorganized internal signals for improved clarity and correctness, including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
2025-07-23 Update th9958_progress.xlsx documentation
    Modified the th9958_progress.xlsx file to reflect recent progress or changes in the project documentation.
2025-07-24 Refactor VDP cartridge logic and signal names
    Updated RTL implementation for the tangnano20k VDP cartridge, including significant refactoring of internal wire and signal names, LUT logic, and register assignments. These changes improve code clar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
2025-07-26 Update VDP logic and timing control modules
    Refactors and expands the VDP timing control logic, including changes to LUT definitions, signal wiring, and module interfaces. Updates include new and renamed outputs, adjustments to combinational l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
2025-07-27 Refactor VDP timing control and update test assets
    Major refactoring of vdp_timing_control_ssg module interface and internal logic, including renaming and restructuring of ports and signals for clarity and expanded functionality. Updated related synt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
2025-07-28 Refactor and update VDP timing and LED control logic
    Reworked LUT and wire assignments in tangnano20k_vdp_cartridge.vg, including significant changes to VDP timing control, LED logic, and signal naming. Updated module interfaces and internal connection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
2025-07-29 Add SCREEN5 image display and refactor test code
    Added SCREEN5 image display routine and test cases to soft_vdp_test2.asm. Refactored common constant definitions into lib.asm and updated references in test programs. Improved VRAM address setup in l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
2025-08-01 Refactor VDP cartridge logic and add sprite disable
    Updated RTL and implementation files for tangnano20k_vdp_cartridge_step7, including significant refactoring of signal names and LUT logic in vdp_cpu_interface. Added reg_sprite_disable output and cha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
2025-08-03 Refactor display color logic for screen modes
    Introduced w_backdrop_color to handle backdrop color assignment based on screen mode. Updated pattern generation logic to support different screen modes, including more precise handling for SCREEN1, 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
2025-08-05 Remove GPIO and WS2812 LED modules from project
    Eliminated references to ip_gpio and ip_ws2812_led modules from synthesis logs, project files, and source file index. Updated msx_slot interface and logic to remove GPIO dependencies and refactored r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
2025-08-09 Refactor msx_slot and vdp_cpu_interface modules
    Updated msx_slot and vdp_cpu_interface modules to improve signal naming, reorganize input/output ports, and optimize logic for address and data handling. Adjusted clocking and control logic, removed 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
2025-08-11 Refactor VDP interface and address handling logic
    Major updates to the VDP cartridge design, including changes to the msx_slot and vdp_cpu_interface modules. Address and control signal handling has been refactored, with new signals introduced and se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
2025-08-13 Update VDP and testbench files, add new test cases
    Significant updates to vdp_cpu_interface.v and related Verilog modules, including changes to signal names, logic, and interface definitions. Added new test programs (SC4TEST.COM, SC5TEST.COM, TEST.CO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
2025-08-14 Refactor VDP CPU interface and msx_slot logic
    Significant changes to the VDP CPU interface and msx_slot modules, including input/output port reorganization, LUT logic rewrites, and signal renaming. The update improves address decoding, status re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
2025-08-16 Add VDP command cache module and testbench
    Introduced vdp_command_cache.v and its comprehensive SystemVerilog testbench with supporting scripts and documentation. Updated run.bat files to include the new cache module. Updated documentation an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
2025-08-17 Refactor VDP CPU interface and update synthesis files
    Reworked the vdp_cpu_interface module, renaming and reorganizing internal wires and logic for improved clarity and maintainability. Updated synthesis and project files to reflect these changes, inclu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
2025-08-19 Refactor VDP cartridge logic and signal assignments
    Reworks and optimizes the VDP cartridge Verilog netlist, including changes to module ports, LUT logic, and signal assignments. Updates address, interrupt, and register handling, and improves clarity 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
2025-08-19 Update development log for cache and VDP changes
    Revised history.txt to reflect continued cache memory debugging and VDP Command LINE implementation and debugging on August 18 and 19, 2025.
2025-08-22 Update
    cache を大幅に修正する前のバックアップ
2025-08-24 Updated
    screen_mode の規模を削減。LUT 719 → 639
    しかし、CPUからの VRAM書き込みができなくなっている。VRAMアクセス部分は変更していない。
2025-08-25 Updated
    いくつかのバグを潰した
2025-08-26 Updated
    進捗更新
2025-08-27 Updated
    LINE のバグをいくつか修正
2025-08-28 SRCH
2025-08-30 Updated
    SRCH コマンドのテストを一通り実施。
    LINE の上はみ出しで、実機と挙動が異なっていたバグを修正。
2025-09-01 Updated
    YMMM バグフィックス
2025-09-01 Update SC5SRCH
2025-09-02 Bugfixed SC5SRCH
2025-09-05 Bugfix TEXT2
    TEXT2 で、縦縞が入ってしまったり、文字が一部欠けたりするバグを修正。
2025-09-13 Sprite mode1 bug fixed
2025-09-17 Extended Color Palette Mode Implementation Complete
    32768色中256色モードを実装した。
2025-09-21 Added LFMC command
2025-09-22 Added LFMM Command
2025-09-26 Bugfix Sprite mode2 CC bit
2025-09-26 Added R#20 bit1 (SVNS)
2025-09-27 Updated
    sprite mode3 まだ途中
2025-10-05 Implemented VDP Command end interrupt
2025-10-08 Added FIL (Flat interlace mode)
2025-10-10 Removed V9958 OCM-PLD version
2025-10-12 Added DIP S/W support for select the I/O 8xh / 9xh address.
2025-10-15 Added SPS Register on R#25
2025-10-27 Modified SCANLINE
2025-10-28 Bugfix HMMM/LMMM command
2025-10-31 Bugfix line interrupt
2025-11-03 Bugfix SCREEN7/8 Sprite mode2
2025-11-08 Bugfix VRAM Read/Write Access
2025-11-12 Bugfix XHR register
2025-11-13 Bugfix LRMM
2025-11-23 CHKVDP更新
2025-12-30 Bugfix MSX_SLOT.V
    VDPからの読み出し時のデータのラッチと、レベルシフタの方向変換のタイミングを合わせて
    取りこぼすバグを修正。
2026-01-02 Bugfix SRCH
2026-01-11 Bugfix LINE
    LINEコマンドで、垂直方向の移動が壊れていたバグを修正

Notices in the files:
RTL/tangnano20k_vdp_cartridge/pcb/vdp_cartridge.kicad_pcb:
Copyright 2025 HRA!
